## drivers/rekernel/Kconfig
```kconfig
menu "Re:Kernel"

config REKERNEL
	bool "Re:Kernel support"
	default y
	help
	  Make tombstone users get a better experience.

endmenu
```
